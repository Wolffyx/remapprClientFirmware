## src/config/compilers/remappr/__golden__/split_nrf_follower/Kconfig.shield
```kconfig
config SHIELD_SPLIT_NRF_FOLLOWER
	def_bool $(shields_list_contains,split_nrf_follower)
```
