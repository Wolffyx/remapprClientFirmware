## src/config/compilers/remappr/__golden__/remappr_bench14/Kconfig.shield
```kconfig
config SHIELD_REMAPPR_BENCH14
	def_bool $(shields_list_contains,remappr_bench14)
```
